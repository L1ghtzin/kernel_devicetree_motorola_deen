&soc {
	/delete-node/ uart@78b0000;
	/delete-node/ uart@7aef000;
	/delete-node/ adv_vreg;

		fusb302@22 {
			compatible = "fairchild,fusb302";
			reg = <0x22>;
			gpios = <&tlmm 67 1>; /* FUSB302_INT_N, in */
			fusb,gpio-labels = "gpio_fusb_int_n";
			pinctrl-names = "default", "active";
			pinctrl-0 = <&fusb302_int_default>;
			pinctrl-1 = <&fusb302_int_active>;
		};

		usb3813@2D {
			compatible = "microchip,usb3813";
			reg = <0x2D>;
			pinctrl-0 = <&hub_reset_n_default &hub_int_n_default>;
			pinctrl-names = "default";
			gpios = <&tlmm 74 0x20>,   /* HUB_RESET_EN */
				<&tlmm 48 1>;   /* HUB_INT_N */
			gpio-labels = "gpio_hub_reset_n",
				"gpio_hub_int_n";
			clock-names = "hub_clk";
			clocks = <&clock_gcc clk_bb_clk2>;
			switch-usbhost;
			vdd-hsic-supply = <&pm8953_l23>;
		};
	};

		motosh@43 {
			compatible = "stm,motosh";
			reg = <0x43>;
			gpios = <&tlmm 129 0>,  /* IRQ     CCP_AP_INT2  */
				<&tlmm  31 0>,  /* RESET   CCP_FAULT_N  */
				<&tlmm   8 0>,  /* BSLEN   CCP_FLASH_EN */
				<&tlmm   9 0>,  /* WakeIRQ CCP_AP_INT   */
				<&tlmm 128 0>,  /* SH Wake AP_CCP_WAKE  */
				<&tlmm  12 0>;  /* SH Wake Resp CCP_AP_WAKE */
			motosh_fw_version = "stml47x";
			lux_table = <7 60 120 1800 4245 11350>;
			brightness_table = <5 15 23 48 70 102 168>;
			qd_pm_qos_latency = <350>;
			qd_pm_qos_timeout = <500000>;
			bslen_pin_active_value = <1>;
			ct406_detect_threshold = <0x0096>;
			ct406_undetect_threshold = <0x0050>;
			ct406_recalibrate_threshold = <0x0064>;
			ct406_pulse_count = <0x03>;
			ct406_prox_gain = <0x02>;
			ct406_als_lux1_c0_mult = <0x49C>; /* 1180 */
			ct406_als_lux1_c1_mult = <0x8CC>; /* 2252 */
			ct406_als_lux1_div = <0x80>;      /* 128 */
			ct406_als_lux2_c0_mult = <0x129>; /* 297 */
			ct406_als_lux2_c1_mult = <0x1E6>; /* 486 */
			ct406_als_lux2_div = <0x80>;      /* 128 */
			sensor1-supply = <&pm8953_l6>;
			sensor2-supply = <&pm8953_l22>;
			accel_orient = <3>;     /* Accel Orientation value */
			gyro_orient = <3>;      /* Gyro Orientation value */
			mag_orient =  <11>;     /* Mag Orientation value */
			mag_config = <5>;       /* Magnetometer config value */
			panel_type = <1>;       /* Panel Type value */
			IR_config = <1>;        /* IR Config value */
			cover_detect_polarity = <1>; /*MOTOSH_SOUTH_DETECT*/
			pinctrl-names = "default";
			pinctrl-0 = <&pmx_motosh_out &pmx_motosh_in>;
			antcap_cfg = [54 21 03 00 00 0a 52 00 00 0b e7 00 00 09 9f 00 00 12 74 13 88 00 00 00 00 80 00 14 1e 00 a4 13 ec 00 00 00 00 00 de ad be ef 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 00 ];
			headset_detect_enable = <1>;
			headset_insertion_debounce = <0x01F4>;
			headset_removal_debounce = <0x0080>;
			headset_button_down_debounce = <0x0032>;
			headset_button_up_debounce = <0x0032>;
			headset_button_0-1_threshold = <0x009D>;
			headset_button_1-2_threshold = <0x0145>;
			headset_button_2-3_threshold = <0x0201>;
			headset_button_3-upper_threshold = <0x03B0>;
			headset_button_1_keycode = <0xE2>; /* KEY_MEDIA */
			headset_button_2_keycode = <0x246>;/* KEY_VOICECOMMAND */
			headset_button_3_keycode = <0x73>; /* KEY_VOLUMEUP */
			headset_button_4_keycode = <0x72>; /* KEY_VOLUMEDOWN */
		};
	};

	spi_6: spi@7af6000 { /* BLSP2 QUP2 */
		status = "ok";
		compatible = "qcom,spi-qup-v2";
		#address-cells = <1>;
		#size-cells = <0>;
		reg-names = "spi_physical", "spi_bam_physical";
		reg = <0x07af6000 0x600>,
		<0x07ac4000 0x1f000>;
		interrupt-names = "spi_irq", "spi_bam_irq";
		interrupts = <0 300 0>, <0 239 0>;
		spi-max-frequency = <19200000>;

		qcom,infinite-mode = <0>;
		qcom,use-bam;
		qcom,ver-reg-exists;
		qcom,bam-consumer-pipe-index = <6>;
		qcom,bam-producer-pipe-index = <7>;
		qcom,master-id = <84>;
		qcom,use-pinctrl;
		pinctrl-names = "spi_default", "spi_sleep";
		pinctrl-0 = <&spi_6_active &spi6_cs0_active>;
		pinctrl-1 = <&spi_6_sleep &spi6_cs0_sleep>;

		clock-names = "iface_clk", "core_clk";

		clocks = <&clock_gcc clk_gcc_blsp2_ahb_clk>,
			<&clock_gcc clk_gcc_blsp2_qup2_spi_apps_clk>;
	};

	spi_8: spi@7af8000 { /* BLSP2 QUP3 */
		compatible = "qcom,spi-qup-v2";
		status = "ok";
		#address-cells = <1>;
		#size-cells = <0>;
		reg-names = "spi_physical";
		reg = <0x07af8000 0x600>;
		interrupt-names = "spi_irq";
		interrupts = <0 302 0>;
		spi-max-frequency = <19200000>;

		pinctrl-names = "spi_default", "spi_sleep";
		pinctrl-0 = <&spi_8_active>;
		pinctrl-1 = <&spi_8_sleep>;
		qcom,infinite-mode = <0>;
		qcom,master-id = <84>;
		qcom,use-pinctrl;

	};

	/* currus 1.2V supply TPS6267001 */
	cdc_1p2v: cdc_1p2v {
		status = "disabled";
		compatible = "regulator-fixed";
		regulator-name = "cdc_1p2v";
		enable-active-high;
		gpio = <&tlmm 126 0>;
	};

	blsp2_uart1: uart@7aef000 { /* BLSP2 UART1 */
		compatible = "qcom,msm-hsuart-v14";
		reg = <0x7aef000 0x200>,
			<0x7ac4000 0x1f000>;
		reg-names = "core_mem", "bam_mem";

		interrupt-names = "core_irq", "bam_irq", "wakeup_irq";
		#address-cells = <0>;
		interrupt-parent = <&blsp2_uart1>;
		interrupts = <0 1 2>;
		#interrupt-cells = <1>;
		interrupt-map-mask = <0xffffffff>;
		interrupt-map = <0 &intc 0 306 0
				1 &intc 0 239 0
				2 &tlmm 17 0>;

		qcom,tx-gpio = <&tlmm 16 0>;
		qcom,rx-gpio = <&tlmm 17 1>;
		qcom,cts-gpio = <&tlmm 18 0>;
		qcom,rts-gpio = <&tlmm 19 1>;
		qcom,master-id = <84>;
		clock-names = "core_clk", "iface_clk";
		clocks = <&clock_gcc clk_gcc_blsp2_uart1_apps_clk>,
			<&clock_gcc clk_gcc_blsp2_ahb_clk>;
		qcom,bam-tx-ep-pipe-index = <0>;
		qcom,bam-rx-ep-pipe-index = <1>;
		qcom,msm-bus,name = "blsp2_uart1";
		qcom,msm-bus,num-cases = <2>;
		qcom,msm-bus,num-paths = <1>;
		qcom,msm-bus,vectors-KBps =
				<84 512 0 0>,
				<84 512 500 800>;
		status = "ok";
	};

	mod_uart {
		compatible = "mmi,mod-uart";
		mmi,tty = "ttyHS5";
		mmi,tty_speed = <115200>;
		mmi,intf-id = /bits/ 8 <5>;

		pinctrl-names = "default", "active";
		pinctrl-0 = <&blsp2_uart1_sleep>;
		pinctrl-1 = <&blsp2_uart1_active>;
	};

	muc: muc {
		compatible = "mmi,muc";
		#address-cells = <1>;
		#size-cells = <1>;
		ranges = <0 0 0xffffffff>;

		gpios = <&tlmm 60 1>,         /* gpio_muc_det_n, input */
			<&pmi8950_gpios 1 0>, /* gpio_muc_bplus_en, output-low */
			<&tlmm 72 1>,         /* gpio_muc_int_n, input */
			<&tlmm 38 2>,         /* gpio_muc_wake_n, output-high */
			<&tlmm 59 1>,         /* gpio_muc_rdy_n, input */
			<&pmi8950_mpps 1 0>,  /* gpio_muc_ff, output-low */
			<&tlmm 0 0>,          /* gpio_muc_spi_mosi, output-low */
			<&tlmm 1 1>,          /* gpio_muc_spi_miso, input */
			<&tlmm 114 2>,        /* gpio_muc_bplus_iset, output-high */
			<0>,                  /* gpio_muc_bplus_discharg, cs */
			<&pmi8950_mpps 4 1>,  /* gpio_muc_bplus_fault_n, input */
			<&tlmm 3 1>;          /* gpio_muc_clk, input */

		mmi,muc-ctrl-gpio-labels = "gpio_muc_det_n",
					"gpio_muc_bplus_en",
					"gpio_muc_int_n",
					"gpio_muc_wake_n",
					"gpio_muc_rdy_n",
					"gpio_muc_ff",
					"gpio_muc_spi_mosi",
					"gpio_muc_spi_miso",
					"gpio_muc_bplus_iset",
					"gpio_muc_bplus_discharg",
					"gpio_muc_bplus_fault_n",
					"gpio_muc_clk";

		/* Addison has shared muc/flash SPI. */
		mmi,spi-shared-with-flash;

		mmi,muc-ctrl-det-hysteresis = <200>;
		mmi,muc-ctrl-rm-hysteresis = <5>;
		mmi,muc-ctrl-en-seq = <1 1 100>;
		mmi,muc-ctrl-dis-seq = <1 0 505>;

		/* v1 FF first, BPLUS second on enable */
		mmi,muc-ctrl-ff-seq-v1 = <5 1 20>, <1 0 100>,
					<1 1 100>, <5 0 20>;

		/* v2 BPLUS first, FF second on enable */
		mmi,muc-ctrl-ff-seq-v2 = <1 1 100>, <5 1 20>,
					<5 0 20>;

		pinctrl-names = "disconnected", "spi_active", "spi_ack", "i2c_active";
		pinctrl-0 = <&muc_attach &spi_1_sleep &muc_spi_ctrl &spi1_cs0_sleep &muc_bplus_ilim>;
		pinctrl-1 = <&muc_attach &spi_1_active &muc_spi_ctrl &spi1_cs0_active &muc_bplus_ilim>;
		pinctrl-2 = <&spi_1_mosi_ack &spi_1_miso_ack>;
		pinctrl-3 = <&muc_attach &i2c_1_active &muc_spi_ctrl &muc_bplus_ilim>;

		transports {
			#address-cells = <1>;
			#size-cells = <1>;
			ranges = <0 0 0xffffffff>;

			/* Placeholder for SPI defined later */
			spi_1: spi@78b5000 { };

			/* Placeholder for I2C defined later */
			i2c_1: i2c@78b5000 { };
		};
	};

	muc_svc: muc_svc@0 {
		compatible = "mmi,muc_svc";

		mmi,use-authentication;
		mmi,endo-mask = <0x4755>;
		mmi,default-root-ver = /bits/ 8 <2>;
	};

	apba_ctrl {
		compatible = "mmi,apba-ctrl";
		reg = <0 0>;
		clock-names = "apba_mclk";
		clocks = <&clock_gcc clk_bb_clk2>;
		pinctrl-names = "default", "spi_active";
		pinctrl-0 = <&apba_default &spi1_cs1_sleep>;
		pinctrl-1 = <&apba_default &spi1_cs1_active>;
		gpios = <&tlmm 39 0>,      /* APBA_1P1_EN, output-low */
			<&tlmm 140 0>,     /* APBA_BOOTRET, output-low */
			<&pmi8950_mpps 2 2>, /* MOD_MPHY_I2S_SEL, output-high */
			<&tlmm 132 0>,     /* APBA_RESET_N, output-low */
			<&tlmm 62 1>,      /* APBA_INT_N, in */
			<&tlmm 141 0>,     /* APBA_WAKE, output-low */
			<&tlmm 41 0>;      /* APBA_SFLASH_EN, output-low */
		mmi,gpio-labels = "gpio_apba_1p1_en",
				  "gpio_apba_bootret",
				  "gpio_mphy_i2s_sel",
				  "gpio_apba_rst_n",
				  "gpio_apba_int_n",
				  "gpio_apba_wake",
				  "gpio_apba_sflash_en";
		mmi,int-index = <4>;
		/* Notes about boot sequence:  w25q40bw spec says 10 usec needed
		   from VCC high to first /CS low for read.  It requires 10 msec max
		   until first write. */
		/* ES3 AP Bridge power on sequence requires 40 usec minimum between
		   (APBA_VDDIO + SYS_CLK) and SYS_RESET_N high, and requires RESET_N low during
		   boot. */
		mmi,enable-preclk-seq = <6 0 0>, <3 0 0>, <5 1 0>, <0 1 0>,
				 <1 0 0>, <2 0 1>;
		mmi,enable-postclk-seq = <3 1 0>;
		mmi,disable-seq = <1 0 0>, <2 1 0>, <3 0 1>, <5 0 0>, <0 0 0>;
		mmi,wake-assert-seq = <5 0 0>;
		mmi,wake-deassert-seq = <5 1 0>;
		mmi,flash-start-seq = <6 1 0>, <0 1 11>;
		mmi,flash-end-seq = <0 0 0>, <6 0 0>;
		mmi,apba-unipro-mid = <0x00000126>;
		mmi,apba-unipro-pid = <0x00001001>;
		mmi,apba-ara-vid = <0xfed70128>;
		mmi,apba-ara-pid = <0xfffe0001>;
	};

	mods_camera_ext {
		compatible = "mmi,mods-camera-ext";
		camera_ext_cdsi-supply = <&pm8953_l23>;
	};

	mods_v4l2_hal {
		compatible = "mmi,mods-v4l2_hal";
	};

	mods_codec_shim {
		compatible = "mmi,mods-codec-shim";
	};

	usb3: ssusb@7000000{
		mmi,qos_latency = <10999>;
		vbus_dwc3-supply = <&usb_otg_switch>;
		pinctrl-names = "default";
		pinctrl-0 = <&otg_en_default &otg_fault_default>;
		qcom,otg-fault-gpio = <&tlmm 34  0x1>; /* GPIOF_IN*/
		psy,type-c;
		qcom,ssusb-compliance;
		dwc3@7000000 {
			controller-number = /bits/ 8 <1>;
		};
	};

	fsusb42 {
		compatible = "fairchild,fsusb42";
		gpios = <&pm8953_gpios 6 0>; /* USB_SELECT, output-low */
		gpio-names = "gpio_fsusb_select";
		vdd-fsusb42-supply = <&pm8953_l13>;
		status = "okay";
	};

	hd3ss460 {
		compatible = "ti,hd3ss460";
		pinctrl-names = "default", "active";
		pinctrl-0 = <&hd3ss460_amsel_default>;
		pinctrl-1 = <&hd3ss460_amsel_active>;
		gpios = <&pm8953_gpios 7 0>, /* USB_SS_MOD_EN, output-low */
			<&tlmm 130 0>,       	 /* USB_SS_SW_SEL, output-low */
			<&pm8953_gpios 8 0>; /* USB_SS_MOD_MPHY_AP_EN, output-low */
		hd3-gpio-labels = "gpio_hd3ss460_pol",
				"gpio_hd3ss460_amsel",
				"gpio_hd3ss460_en";
		vdd-hd3ss460-supply = <&pm8953_l6>;
		vdd-voltage-level = <1800000 1800000>;
		vdd-current-level = <200 30000>;
	};

	qusb_phy: qusb@79000 {
		qcom,qusb-phy-init-seq = <0x73 0x80
					0x72 0x84
					0x07 0x88
					0x13 0x8C
					0x30 0x08
					0x79 0x0C
					0x21 0x10
					0x14 0x9C
					0x9F 0x1C
					0x00 0x18>;
	};

	usb_otg_switch: usb-otg-switch {
		compatible = "regulator-fixed";
		regulator-name = "usb_otg_vreg";
		vin-supply = <&smbcharger_external_otg>;
		enable-active-high;
		gpio = <&tlmm 109 0>;
		status = "okay";
	};

};

&spi_1 { /* BLSP1 QUP1 */
	status = "ok";
	compatible = "qcom,spi-qup-v2", "moto,mod-spi-transfer";
	#address-cells = <1>;
	#size-cells = <0>;
	reg-names = "spi_physical", "spi_bam_physical";
	reg = <0x078b5000 0x600>,
	<0x07884000 0x1f000>;
	interrupt-names = "spi_irq", "spi_bam_irq";
	interrupts = <0 95 0>, <0 238 0>;
	spi-max-frequency = <48000000>;

	qcom,infinite-mode = <0>;
	qcom,use-bam;
	qcom,ver-reg-exists;
	qcom,bam-consumer-pipe-index = <4>;
	qcom,bam-producer-pipe-index = <5>;
	qcom,master-id = <86>;
	qcom,rt-priority;
	qcom,active-only;

	clock-names = "iface_clk", "core_clk";

	clocks = <&clock_gcc clk_gcc_blsp1_ahb_clk>,
		<&clock_gcc clk_gcc_blsp1_qup1_spi_apps_clk>;


	muc_spi: muc_spi@0 {
		compatible = "moto,muc_spi";
		reg = <0>;
		interrupt-parent = <&tlmm>;
		interrupts = <72 0>;
		spi-max-frequency = <4800000>;

		mmi,intf-id = /bits/ 8 <3>;
	};

	apba_flash: m25p80@1 {
		compatible = "w25q40ew";
		reg = <1>;
		spi-max-frequency = <4800000>;
		#address-cells = <1>;
		#size-cells = <1>;

		partition@0 {
			label = "apba";
			reg = <0x0 0x40000>;
		};
		partition@1 {
			label = "es2_apbaboot";
			reg = <0x0 0x4000>;
		};
		partition@2 {
			label = "es2_apba";
			reg = <0x4000 0x3C000>;
		};
	};
};

/* for mods i2c */
&i2c_1 {
	compatible = "qcom,i2c-msm-v2", "moto,mod-i2c-transfer";
	#address-cells = <1>;
	#size-cells = <0>;
	reg-names = "qup_phys_addr";
	reg = <0x78b5000 0x600>;
	interrupt-names = "qup_irq";
	interrupts = <0 95 0>;
	dmas = <&dma_blsp1 4 64 0x20000020 0x20>,
		<&dma_blsp1 5 32 0x20000020 0x20>;
	dma-names = "tx", "rx";
	qcom,master-id = <86>;
	qcom,clk-freq-out = <400000>;
	qcom,clk-freq-in  = <19200000>;
	clock-names = "iface_clk", "core_clk";
	clocks = <&clock_gcc clk_gcc_blsp1_ahb_clk>,
		 <&clock_gcc clk_gcc_blsp1_qup1_i2c_apps_clk>;

	muc_i2c@42 {
		compatible = "moto,muc_i2c";
		reg = <0x42>;
		interrupt-parent = <&tlmm>;
		interrupts = <72 0>;

		mmi,intf-id = /bits/ 8 <3>;
	};
};
